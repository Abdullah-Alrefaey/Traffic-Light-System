# Keil uVision project Elevator System.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: ElevatorSystem +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
    ./lib/: button.c button.h DIO.c DIO.h interrupt.c interrupt.h LED.c LED.h std_macros.h delay.c delay.h stepperMotor.c stepperMotor.h Seven_Segment.c Seven_Segment.h
