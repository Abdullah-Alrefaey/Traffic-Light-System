# Keil uVision project Traffic_Light.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8031AH Intel
  cpu: IRAM(0-0x7F) CLOCK(12000000)
  output: Traffic_Light
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Traffic_Light.A51
