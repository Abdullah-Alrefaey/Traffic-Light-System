# Keil uVision project TrafficLightDemo.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C31BH Intel
  cpu: IRAM(0-0x7F) CLOCK(24000000)
  output: TrafficLightDemo +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: TrafficLightDemo.A51
